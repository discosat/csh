options:
  parameters:
    generate_options: qt_gui
    id: test_GS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_var
  id: variable_qtgui_range
  parameters:
    start: '-150000'
    step: '100'
    stop: '150000'
    value: '83000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      The FSK demodulation
      happens here
    gain: '5'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-90'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/luisito/Development/ITU/space/decode/raw_data/gqrx_20260504_134331_437060000_4000000_fc.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters:
    comment: |-
      Make a hard descision on the
      soft bits
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import pmt
       
      class msg_block(gr.basic_block):
          '''
          Remove stuffed bits from a message i.e, the bits followed by 
          five consequitive ones. 
          '''
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Bit de-stuffer",
                  in_sig=None,
                  out_sig=None)


              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              #Get bitstream from message
              bitstream = np.array(pmt.to_python(msg)) 
              

              """Remove one bit preceded by five consequitive ones"""
              compare_array = np.array([1,1,1,1,1])


              for i in range(len(bitstream)-5):
                  if np.array_equal(bitstream[i:i+5],compare_array):
                      #Mark stuffed bits such that they can be removed later
                      #If they are removed now, the for loop will delete all
                      #consequtive bits if 1111101 is received
                      bitstream[i+5] = 2


              bitstream_destuffed = np.delete(bitstream, np.where(bitstream == 2))

              #Convert destuffed frame to PMT
              outgoing_msg = pmt.init_u8vector(len(bitstream_destuffed),(bitstream_destuffed))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('pdu_out'), pdu)
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          This block srcrambles an input PDU consisting of unpacked bytes.
          The Additive scrambling is compliant with the 255-bit pseudo-randomizer
          desribed in section 10 in CCSDS 131.0-B-5 (TM Blue Book)

          Note: as the scrambler is additive, applying it twice will return
          the original message. 

          PDU_in:  unpacked bits
          PDU_out: scrambled unpacked bits
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CCSDS Additive Scrambler',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.pn_lut = np.zeros(255, dtype=np.uint8)
              self.generate_pn_lut()

              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              scr_bitstream = np.zeros(len(bitstream), dtype=np.uint8) 
              for i in range(len(bitstream)):
                  scr_bitstream[i] = np.uint8(bitstream[i]) ^ np.uint8(self.pn_lut[i%255])

              #Convert the scrambled bitstream to PDU
              outgoing_msg = pmt.init_u8vector(len(scr_bitstream),(scr_bitstream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
          
          def generate_pn_lut(self):

              #Define shift register
              sr = 0b11111111
              
              #Update shift register
              for i in range(255):
                  self.pn_lut[i] = sr & 1
                  nb = self.pn_xor(sr)
                  sr = sr >> 1
                  sr = sr | (nb << 7)
                  
                  
          def pn_xor(self, sr):
              return (((sr & 0b01) >> 0) ^ ((sr & 0b00001000) >> 3) ^ ((sr & 0b00100000) >> 5) ^ ((sr & 0b10000000) >> 7)) & 1
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import pmt
       
      class msg_block(gr.basic_block):
          '''
          Gets a message with the front HDLC flag removed by the
          'sync and create PDU block' and this block then removes
          the last HDLC flag and sends the prior bitstream
          '''
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="HDLC Deframer",
                  in_sig=None,
                  out_sig=None)


              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              #Get bitstream from message
              bitstream = np.array(pmt.to_python(pmt.cdr(msg))) 


              hdlc_flag = np.array([0,1,1,1,1,1,1,0])
              hdlc_index = 0
              
              #Find HDLC in bitstream
              for i in range(len(bitstream)-len(hdlc_flag)):
                  bitstream_snippet = bitstream[i:i+len(hdlc_flag)]
                  if (np.array_equal(bitstream_snippet,hdlc_flag)):
                      hdlc_index = i
                      break
              
              #localize HDLC frame
              hdlc_frame = bitstream[0:hdlc_index]


              #Convert HDLC frame to PMT
              outgoing_msg = pmt.to_pmt(hdlc_frame)

              self.message_port_pub(pmt.intern('msg_out'), outgoing_msg)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          PDU_in: 1,0,1,0,1,0,1,0 (ex)
          PDU_out: 0xAA
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Pack 8 bits',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              bytestream = np.packbits(bitstream)


              #Convert the bytestream to PDU
              outgoing_msg = pmt.init_u8vector(len(bytestream),(bytestream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '10000'
    comment: +83000 to center at 437
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -20e3,20e3, 5e3)
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/50
    fc: '437060000'
    fftsize: '1024'
    rate: '30'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/1
    fc: '436989500'
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/100
    type: float
  states: {state: disabled}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {}
- name: satellites_fsk_demodulator_1
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    comment: |-
      Timing synchronization
      and soft bit output
    samp_rate: samp_rate/50
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    comment: |-
      Find sync sequence and create 
      a PDU if found
    packlen: '689'
    sync: '"0101010101010101010101010111111010101010"'
    threshold: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 437e6
    gain0: '80'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: synced_message
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: 'From here: FEC and descambling etc'
    stream_id: synced_message
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_agc_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_binary_slicer_fb_1, '0', satellites_sync_to_pdu_0, '0']
- [epy_block_0_0, pdu_out, epy_block_0_1, PDU_in]
- [epy_block_0_1, PDU_out, epy_block_2, PDU_in]
- [epy_block_1, msg_out, epy_block_0_0, msg_in]
- [epy_block_2, PDU_out, satellites_decode_rs_ccsds_0, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_1, print]
- [satellites_fsk_demodulator_1, '0', digital_binary_slicer_fb_1, '0']
- [satellites_sync_to_pdu_0, out, virtual_sink_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0, '0']
- [virtual_source_0, '0', satellites_fsk_demodulator_1, '0']
- [virtual_source_1, '0', epy_block_1, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
