options:
  parameters:
    author: Luis Landa
    description: Decodes PE0SAT DISCO-2 recordings (312.5 kHz, 437.075 MHz center)
    generate_options: qt_gui
    id: pe0sat_disco2_decode
    output_language: python
    title: PE0SAT DISCO-2 Recordings Decoder
  states: {}

blocks:
- name: center_offset
  id: variable_qtgui_range
  parameters:
    comment: Frequency offset of signal from SDR center (Hz)
    label: Center Offset
    start: '-15000'
    step: '100'
    stop: '15000'
    value: '4000'
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: Decimation factor. 10 -> 31250 Hz output (6.5 sps at 4800 baud)
    value: '10'
  states: {}
- name: filter_bw
  id: variable_qtgui_range
  parameters:
    comment: Bandpass filter bandwidth (Hz)
    label: Filter BW
    start: '2000'
    step: '500'
    stop: '30000'
    value: '12000'
  states: {}
- name: fm_gain
  id: variable_qtgui_range
  parameters:
    comment: FM demodulation gain
    label: FM Gain
    start: '1'
    step: '0.5'
    stop: '20'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '312500'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: fm_gain
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      -90 works for NL recordings, 
      ITU passes are too weak so set to -150 or bypass
    threshold: '-90'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Can be bypased if computer is 
      powerful enough to handle
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      So far, only 
      sdrpp_baseband_437075000Hz_2026-04-30T151430.wav
      has been decoded
      this grc file only works for that file atm
    file: sdrpp_baseband_437075000Hz_2026-04-30T151430.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      HDLC Bit De-stuffer
      Removes one bit preceded by five consecutive ones (HDLC bit-stuffing)
      """

      from gnuradio import gr
      import numpy as np
      import pmt

      class msg_block(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Bit de-stuffer",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(msg))

              compare_array = np.array([1,1,1,1,1])
              for i in range(len(bitstream)-5):
                  if np.array_equal(bitstream[i:i+5], compare_array):
                      bitstream[i+5] = 2

              bitstream_destuffed = np.delete(bitstream, np.where(bitstream == 2))

              outgoing_msg = pmt.init_u8vector(len(bitstream_destuffed), (bitstream_destuffed))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)
              self.message_port_pub(pmt.intern('pdu_out'), pdu)
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      CCSDS Additive Descrambler
      Compliant with CCSDS 131.0-B-5 Section 10
      Applying twice returns the original message.
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='CCSDS Additive Scrambler',
                  in_sig=None,
                  out_sig=None)

              self.pn_lut = np.zeros(255, dtype=np.uint8)
              self.generate_pn_lut()

              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              scr_bitstream = np.zeros(len(bitstream), dtype=np.uint8)
              for i in range(len(bitstream)):
                  scr_bitstream[i] = np.uint8(bitstream[i]) ^ np.uint8(self.pn_lut[i%255])

              outgoing_msg = pmt.init_u8vector(len(scr_bitstream), (scr_bitstream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)
              self.message_port_pub(pmt.intern('PDU_out'), pdu)

          def generate_pn_lut(self):
              sr = 0b11111111
              for i in range(255):
                  self.pn_lut[i] = sr & 1
                  nb = self.pn_xor(sr)
                  sr = sr >> 1
                  sr = sr | (nb << 7)

          def pn_xor(self, sr):
              return (((sr & 0b01) >> 0) ^ ((sr & 0b00001000) >> 3) ^ ((sr & 0b00100000) >> 5) ^ ((sr & 0b10000000) >> 7)) & 1
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      HDLC Deframer
      Removes the trailing HDLC flag from sync_to_pdu output
      """

      from gnuradio import gr
      import numpy as np
      import pmt

      class msg_block(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="HDLC Deframer",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))

              hdlc_flag = np.array([0,1,1,1,1,1,1,0])
              hdlc_index = 0
              for i in range(len(bitstream)-len(hdlc_flag)):
                  bitstream_snippet = bitstream[i:i+len(hdlc_flag)]
                  if np.array_equal(bitstream_snippet, hdlc_flag):
                      hdlc_index = i
                      break

              hdlc_frame = bitstream[0:hdlc_index]
              outgoing_msg = pmt.to_pmt(hdlc_frame)
              self.message_port_pub(pmt.intern('msg_out'), outgoing_msg)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Pack 8 bits into bytes
      Drops frames shorter than 32 bytes (noise false triggers)
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Pack 8 bits',
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              try:
                  bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              except Exception:
                  return
              if len(bitstream) < 256:
                  return
              bytestream = np.packbits(bitstream)
              if len(bytestream) < 32:
                  return

              outgoing_msg = pmt.init_u8vector(len(bytestream), (bytestream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)
              self.message_port_pub(pmt.intern('PDU_out'), pdu)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_offset
    comment: |-
      center_offset value shifts signal to baseband 
      filter_bw determines width of bandpass filter
       decimation... needs research but afaik must at least
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -filter_bw/2, filter_bw/2, 1000)
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '20000'
    fc: '437075000'
    fftsize: '2048'
    name: Post Filter GUI
    rate: '100'
    showrf: 'True'
    type: complex
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    comment: CCSDS conventional basis (NOT dual). Interleave=1.
    interleave: '1'
  states: {}
- name: satellites_fsk_demodulator_1
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    comment: |-
      DISCO2 transmits at 4800 baud.
      Following Nyquist-Shannon sampling theorem. 
      a minimum of 9600Hz after decimation is good
      to avoid data loss. Any value of decimation that puts 
      the sample rate below 9600 will result in warnings and
      in the case of weak signals data loss/undecodability.

      btw this block also performs clock recovery
    samp_rate: samp_rate/decimation
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    comment: |-
      Finds DISCO-2 sync word and create PDU

      NL signal is very good, so can run at treshold 0
      DK needs a treshold of 2 to find and succesfully
      deconde packets

      Pack length for succesful terrestiral ping decoding was 689,
      but that is too low for the data sent from space,
      at 1200 we get packets and are able to decode them,
      could be lower though 1200 seems to be ok
      number was arrived at by random choice, 
      would be nice to know how this impacts the overall
      pipline. Tested with 900 and also works
    packlen: '1200'
    sync: '"0101010101010101010101010111111010101010"'
    threshold: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: synced_message
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: 'From here: FEC and descrambling etc'
    stream_id: synced_message
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_binary_slicer_fb_1, '0', satellites_sync_to_pdu_0, '0']
- [epy_block_0_0, pdu_out, epy_block_0_1, PDU_in]
- [epy_block_0_1, PDU_out, epy_block_2, PDU_in]
- [epy_block_1, msg_out, epy_block_0_0, msg_in]
- [epy_block_2, PDU_out, satellites_decode_rs_ccsds_0, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_1, print]
- [satellites_fsk_demodulator_1, '0', digital_binary_slicer_fb_1, '0']
- [satellites_sync_to_pdu_0, out, virtual_sink_1, '0']
- [virtual_source_0, '0', satellites_fsk_demodulator_1, '0']
- [virtual_source_1, '0', epy_block_1, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
