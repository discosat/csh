options:
  parameters:
    generate_options: qt_gui
    id: csp_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 437e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      1.2e6 for BladeRF
      3e6 for HackRF
    value: 1.2e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: freq
    type: float
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: '"tx_eob"'
    false_value: 'False'
    true_key: '"tx_sob"'
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/thomas/Desktop/GFSK_test.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/thomas/Desktop/csp_packet.bin
    type: byte
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: 'PING/5sec: GS --> DISCO1'
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(10,(0x80, 0x81, 0x02, 0xc8, 0x15, 0x41, 0x00, 0x00, 0x00, 0x00)))
    period: '3000'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    comment: 'PING/5sec: DISCO1 --> GS'
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(10,(0x80,0xB2,0x02,0x05,0x50,0x41,0x00,0x00,0x00,0x00)))
    period: '5000'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 250*687
    type: complex
  states: {}
- name: blocks_tag_gate_2
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '300'
    pre_padding: '0'
    type: complex
    window: ([1])
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.8'
    comment: |-
      sps: 250, sens: 0.0167 for BladeRF
      sps: 625, sens: 0.0067 for HackRF
    do_unpack: 'False'
    samples_per_symbol: '250'
    sensitivity: '0.0167'
  states: {}
- name: disco_ZMQ_source_0
  id: disco_ZMQ_source
  parameters:
    connection_str: tcp://127.0.0.1:6000
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    This block takes packed bits and looks for 5 consequitive 1 bits,\n    which upon discovy a 0 bit it inserted right after the 5 consequitive bits. \n\n    PDU_in: packed bits (bytes)\n    PDU_out: unpacked bits\n    \"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Bit stuffer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None,\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern('PDU_in'))\n        self.message_port_register_out(pmt.intern('PDU_out'))\n        self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        #Get bytestream from PDU\n        bytestream = np.array(pmt.to_python(pmt.cdr(msg))) \n\n        #Convert from bytestream to bitstream\n        bitstream = self.bytes_to_bits(bytestream)\n\n        #Stuff the bitstream\n        stuffed_bitstream = self.bit_stuffing(bitstream)\n        \n        #Convert the stuffed bitstream to PDU\n        outgoing_msg = pmt.init_u8vector(len(stuffed_bitstream),(stuffed_bitstream))\n        pdu = pmt.cons(pmt.make_dict(), outgoing_msg)\n\n        self.message_port_pub(pmt.intern('PDU_out'), pdu)\n\n    def bytes_to_bits(self, byte_array):\n        \n        #Create empty list to hold the binary values\n        binary_list = []\n\n        #Loop over the byte array to extract the bits from each byte\n        for byte in byte_array:\n            #remove the 0b formatting by using the slice function\n            binary_str = bin(byte)[2:] \n\n            #insert zero padding in order to verify leading zeros are present\n            binary_str = binary_str.zfill(8)\n\n            #Insert bits into the binary list one at a time\n            binary_list.extend([int(bit) for bit in binary_str])\n        \n        #Convert list to numpy array\n        binary_array = np.array(binary_list)\n\n        return binary_array\n    \n    def bit_stuffing(self, non_stuffed_array, max_consecutive_ones=5, stuff_bit=0):\n        #create stuffed array to hold the new bitstream\n        stuffed_array = []\n\n        consecutive_ones_counter = 0\n\n        #loop over the non stuffed array\n        for bit in non_stuffed_array:\n            if bit == 1:\n                consecutive_ones_counter += 1\n                if consecutive_ones_counter == max_consecutive_ones:\n                    stuffed_array.extend([bit])\n                    stuffed_array.extend([int(stuff_bit)])\n                    consecutive_ones_counter = 0\n                else:\n                    stuffed_array.extend([bit])\n            else:\n                stuffed_array.extend([bit])\n                consecutive_ones_counter = 0\n\n        return np.array(stuffed_array)\n\n\n"
    comment: Bit stuffing
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          This block srcrambles an input PDU consisting of unpacked bytes.
          The Additive scrambling is compliant with the 255-bit pseudo-randomizer
          desribed in section 10 in CCSDS 131.0-B-5 (TM Blue Book)

          Note: as the scrambler is additive, applying it twice will return
          the original message. 

          PDU_in:  unpacked bits
          PDU_out: scrambled unpacked bits
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CCSDS Additive Scrambler',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.pn_lut = np.zeros(255, dtype=np.uint8)
              self.generate_pn_lut()

              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              scr_bitstream = np.zeros(len(bitstream), dtype=np.uint8) 
              for i in range(len(bitstream)):
                  scr_bitstream[i] = np.uint8(bitstream[i]) ^ np.uint8(self.pn_lut[i%255])

              #Convert the scrambled bitstream to PDU
              outgoing_msg = pmt.init_u8vector(len(scr_bitstream),(scr_bitstream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
          
          def generate_pn_lut(self):

              #Define shift register
              sr = 0b11111111
              
              #Update shift register
              for i in range(255):
                  self.pn_lut[i] = sr & 1
                  nb = self.pn_xor(sr)
                  sr = sr >> 1
                  sr = sr | (nb << 7)
                  
                  
          def pn_xor(self, sr):
              return (((sr & 0b01) >> 0) ^ ((sr & 0b00001000) >> 3) ^ ((sr & 0b00100000) >> 5) ^ ((sr & 0b10000000) >> 7)) & 1
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    This block takes packed bits and looks for 5 consequitive 1 bits,\n    which upon discovy a 0 bit it inserted right after the 5 consequitive bits. \n\n    PDU_in: unpacked RS-FEC and scrambled bits\n    PDU_out: unpacked bits ready to be transmitted\n    \"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='DISCO HDLC Framer',   # will show up in GRC\n            in_sig=None,\n            out_sig=None,\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern('PDU_in'))\n        self.message_port_register_out(pmt.intern('PDU_out'))\n        self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        #Get bytestream from PDU\n        bitstream = np.array(pmt.to_python(pmt.cdr(msg))) \n\n        #Define various sequences and flags\n        preamble = np.array([1,0,1,0,1,0,1,0]) #34 times in the beginning\n        HDLC_flag = np.array([0,1,1,1,1,1,1,0]) #2 times, once before and after msg\n        post_HDLC_preamble = preamble\n        postamble1 = np.array([0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1])\n        postamble2 = np.array([1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,0,0,0,1,1])\n\n        total_preamble = np.array([])\n\n        for i in range(34):\n            total_preamble = np.append(total_preamble,preamble)\n\n        bits_to_be_transmitted = np.concatenate((total_preamble[:-1],HDLC_flag,post_HDLC_preamble,bitstream,HDLC_flag,postamble1,postamble2))\n        \n        #Convert the stuffed bitstream to PDU\n        outgoing_msg = pmt.init_u8vector(len(bits_to_be_transmitted),(bits_to_be_transmitted.astype(np.uint8)))\n        pdu = pmt.cons(pmt.make_dict(), outgoing_msg)\n\n        self.message_port_pub(pmt.intern('PDU_out'), pdu)\n\n\n\n\n"
    comment: |-
      HDLC Framing 
      (and various other bits)
      bits are fully framed now.
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          PDU_in: 1,0,1,0,1,0,1,0 (ex)
          PDU_out: 0xAA
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Pack 8 bits',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              bytestream = np.packbits(bitstream)


              #Convert the bytestream to PDU
              outgoing_msg = pmt.init_u8vector(len(bytestream),(bytestream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          PDU_in: 0xAE (ex.)
          PDU_out: 1,0,1,0,1,1,1,0
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Unpack 8 bits',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bytestream = np.array(pmt.to_python(pmt.cdr(msg))) 
              bitstream = np.unpackbits(bytestream)

              #Convert the bytestream to PDU
              outgoing_msg = pmt.init_u8vector(len(bitstream),(bitstream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '4532'
    verbose: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=0,enable_metadata=1"'
    bb_gain0: '20'
    comment: BladeRF Sink
    freq0: 437e6
    gain0: '40'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '600'
    srate: '1000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.001'
  states: {}
- name: satellites_encode_rs_ccsds_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'False'
    comment: Reed-Solomon Encoding of the packet
    interleave: '1'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: 20e3
    center_freq: 437e6
    comment: HackRF sink
    samp_rate: samp_rate
    type: fc32
    vga: '50'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bb_iq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Rs_encoded_scrambled
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bb_iq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Rs_encoded_scrambled
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '0']
- [blocks_burst_tagger_0, '0', osmosdr_sink_0, '0']
- [blocks_burst_tagger_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_message_strobe_0, strobe, satellites_encode_rs_ccsds_0, in]
- [blocks_message_strobe_0_0, strobe, satellites_encode_rs_ccsds_0, in]
- [blocks_stream_to_tagged_stream_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_tag_gate_2, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_burst_tagger_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_complex_to_mag_0, '0']
- [digital_gfsk_mod_0, '0', virtual_sink_0, '0']
- [disco_ZMQ_source_0, PDU_out, satellites_encode_rs_ccsds_0, in]
- [epy_block_0, PDU_out, epy_block_2, PDU_in]
- [epy_block_0_1, PDU_out, epy_block_2_0, PDU_in]
- [epy_block_2, PDU_out, pdu_pdu_to_tagged_stream_1, pdus]
- [epy_block_2_0, PDU_out, virtual_sink_1, '0']
- [epy_block_3, PDU_out, epy_block_0_1, PDU_in]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [pdu_pdu_to_tagged_stream_1, '0', blocks_char_to_float_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_file_sink_1, '0']
- [pdu_pdu_to_tagged_stream_1, '0', digital_gfsk_mod_0, '0']
- [satellites_encode_rs_ccsds_0, out, epy_block_3, PDU_in]
- [virtual_source_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0, '0', blocks_tag_gate_2, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1, '0', epy_block_0, PDU_in]

metadata:
  file_format: 1
