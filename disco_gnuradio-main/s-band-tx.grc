options:
  parameters:
    author: Edvard
    generate_options: qt_gui
    id: sbandtx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: cons
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {state: disabled}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: 259*8
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e5
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / baudrate)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ed/git/sdr-gnd/binaryfile.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 259*8*2
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1, 1)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: cons
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: disco_ZMQ_sink_0
  id: disco_ZMQ_sink
  parameters:
    connection_str: tcp://127.0.0.1:7777
  states: {state: disabled}
- name: disco_ZMQ_source_0
  id: disco_ZMQ_source
  parameters:
    connection_str: tcp://127.0.0.1:6666
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec
    puncpat: '''11'''
    threadtype: none
  states: {state: disabled}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec
    puncpat: '''11'''
    threadtype: none
  states: {state: disabled}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: enc
    itype: byte
    otype: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 1024*10
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '511'
    samp_rate: samp_rate
    sym_rate: baudrate
    type: fir_filter_ccf
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: baudrate
    differential: 'False'
    f_offset: '0'
    iq: 'True'
    manchester: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: '"differential"'
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {state: disabled}
- name: satellites_ccsds_rs_deframer_1
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: '"differential"'
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {state: disabled}
- name: satellites_ccsds_rs_deframer_1_0
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: '"differential"'
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fec_bits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mod_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fec_bits
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fec_bits
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: mod_sig
  states: {state: disabled}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: mod_sig
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: sig
  states: {state: disabled}

connections:
- [blocks_add_const_vxx_0, '0', satellites_ccsds_rs_deframer_1, '0']
- [blocks_add_const_vxx_0_0, '0', satellites_ccsds_rs_deframer_1_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0, '0', fec_extended_decoder_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repeat_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0_0, '0', satellites_bpsk_demodulator_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_1, '0']
- [digital_diff_encoder_bb_0, '0', fec_generic_encoder_0, '0']
- [disco_ZMQ_source_0, PDU_out, blocks_message_debug_0, print]
- [disco_ZMQ_source_0, PDU_out, pdu_pdu_to_tagged_stream_0, pdus]
- [fec_extended_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_char_to_float_1, '0']
- [fec_generic_encoder_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [fec_generic_encoder_0, '0', virtual_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_2, print]
- [root_raised_cosine_filter_0, '0', soapy_hackrf_sink_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_1, '0']
- [satellites_bpsk_demodulator_0, '0', blocks_delay_0, '0']
- [satellites_bpsk_demodulator_0, '0', fec_extended_decoder_0_0, '0']
- [satellites_bpsk_demodulator_0, '0', satellites_ccsds_concatenated_deframer_0, '0']
- [satellites_ccsds_concatenated_deframer_0, out, blocks_message_debug_1, print]
- [satellites_ccsds_concatenated_deframer_0, out, disco_ZMQ_sink_0, PDU_in]
- [satellites_ccsds_rs_deframer_1, out, blocks_message_debug_1, print]
- [satellites_ccsds_rs_deframer_1, out, disco_ZMQ_sink_0, PDU_in]
- [satellites_ccsds_rs_deframer_1_0, out, blocks_message_debug_1, print]
- [satellites_ccsds_rs_deframer_1_0, out, disco_ZMQ_sink_0, PDU_in]
- [virtual_source_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [virtual_source_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_2, '0', blocks_throttle_0_0, '0']
- [virtual_source_3, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_2, '0']
- [virtual_source_3, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_time_sink_x_2, '0']
- [virtual_source_4, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
