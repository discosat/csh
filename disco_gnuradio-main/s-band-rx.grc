options:
  parameters:
    author: Edvard
    generate_options: qt_gui
    id: sbandrx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: 25e5
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2060000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ed/payloadbrd
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: sbandtlebrd
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: disco_ZMQ_sink_0_0
  id: disco_ZMQ_sink
  parameters:
    connection_str: tcp://127.0.0.1:7777
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: satellites_bpsk_demodulator_0_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: baudrate
    differential: 'False'
    f_offset: '0'
    iq: 'True'
    manchester: 'False'
    samp_rate: samp_rate
  states: {}
- name: satellites_ccsds_rs_deframer_1
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: '"differential"'
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {}
- name: satellites_ccsds_rs_deframer_1_0
  id: satellites_ccsds_rs_deframer
  parameters:
    frame_size: '223'
    precoding: '"differential"'
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', satellites_ccsds_rs_deframer_1, '0']
- [blocks_add_const_vxx_0_0, '0', satellites_ccsds_rs_deframer_1_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_delay_0, '0', fec_extended_decoder_0, '0']
- [blocks_file_source_1, '0', blocks_throttle_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_char_to_float_1, '0']
- [satellites_bpsk_demodulator_0_0, '0', blocks_delay_0, '0']
- [satellites_bpsk_demodulator_0_0, '0', fec_extended_decoder_0_0, '0']
- [satellites_ccsds_rs_deframer_1, out, blocks_message_debug_1_0, print]
- [satellites_ccsds_rs_deframer_1, out, disco_ZMQ_sink_0_0, PDU_in]
- [satellites_ccsds_rs_deframer_1_0, out, blocks_message_debug_1_0, print]
- [satellites_ccsds_rs_deframer_1_0, out, disco_ZMQ_sink_0_0, PDU_in]
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', satellites_bpsk_demodulator_0_0, '0']

metadata:
  file_format: 1
