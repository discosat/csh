options:
  parameters:
    author: thomas
    generate_options: qt_gui
    id: csp_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      The FSK demodulation
      happens here
    gain: '5'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ed/Downloads/gqrx_20230130_120914_437371200_8000000_fc_corespondance_ground_DISCO-I.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters:
    comment: |-
      Make a hard descision on the
      soft bits
  states: {}
- name: disco_ZMQ_sink_0
  id: disco_ZMQ_sink
  parameters:
    connection_str: tcp://127.0.0.1:7000
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import pmt
       
      class msg_block(gr.basic_block):
          '''
          Remove stuffed bits from a message i.e, the bits followed by 
          five consequitive ones. 
          '''
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Bit de-stuffer",
                  in_sig=None,
                  out_sig=None)


              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              #Get bitstream from message
              bitstream = np.array(pmt.to_python(msg)) 
              

              """Remove one bit preceded by five consequitive ones"""
              compare_array = np.array([1,1,1,1,1])


              for i in range(len(bitstream)-5):
                  if np.array_equal(bitstream[i:i+5],compare_array):
                      #Mark stuffed bits such that they can be removed later
                      #If they are removed now, the for loop will delete all
                      #consequtive bits if 1111101 is received
                      bitstream[i+5] = 2


              bitstream_destuffed = np.delete(bitstream, np.where(bitstream == 2))

              #Convert destuffed frame to PMT
              outgoing_msg = pmt.init_u8vector(len(bitstream_destuffed),(bitstream_destuffed))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('pdu_out'), pdu)
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          This block srcrambles an input PDU consisting of unpacked bytes.
          The Additive scrambling is compliant with the 255-bit pseudo-randomizer
          desribed in section 10 in CCSDS 131.0-B-5 (TM Blue Book)

          Note: as the scrambler is additive, applying it twice will return
          the original message. 

          PDU_in:  unpacked bits
          PDU_out: scrambled unpacked bits
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CCSDS Additive Scrambler',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )

              self.pn_lut = np.zeros(255, dtype=np.uint8)
              self.generate_pn_lut()

              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              scr_bitstream = np.zeros(len(bitstream), dtype=np.uint8) 
              for i in range(len(bitstream)):
                  scr_bitstream[i] = np.uint8(bitstream[i]) ^ np.uint8(self.pn_lut[i%255])

              #Convert the scrambled bitstream to PDU
              outgoing_msg = pmt.init_u8vector(len(scr_bitstream),(scr_bitstream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
          
          def generate_pn_lut(self):

              #Define shift register
              sr = 0b11111111
              
              #Update shift register
              for i in range(255):
                  self.pn_lut[i] = sr & 1
                  nb = self.pn_xor(sr)
                  sr = sr >> 1
                  sr = sr | (nb << 7)
                  
                  
          def pn_xor(self, sr):
              return (((sr & 0b01) >> 0) ^ ((sr & 0b00001000) >> 3) ^ ((sr & 0b00100000) >> 5) ^ ((sr & 0b10000000) >> 7)) & 1
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      from gnuradio import gr
      import numpy as np
      import pmt
       
      class msg_block(gr.basic_block):
          '''
          Gets a message with the front HDLC flag removed by the
          'sync and create PDU block' and this block then removes
          the last HDLC flag and sends the prior bitstream
          '''
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="HDLC Deframer",
                  in_sig=None,
                  out_sig=None)


              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              #Get bitstream from message
              bitstream = np.array(pmt.to_python(pmt.cdr(msg))) 


              hdlc_flag = np.array([0,1,1,1,1,1,1,0])
              hdlc_index = 0
              
              #Find HDLC in bitstream
              for i in range(len(bitstream)-len(hdlc_flag)):
                  bitstream_snippet = bitstream[i:i+len(hdlc_flag)]
                  if (np.array_equal(bitstream_snippet,hdlc_flag)):
                      hdlc_index = i
                      break
              
              #localize HDLC frame
              hdlc_frame = bitstream[0:hdlc_index]


              #Convert HDLC frame to PMT
              outgoing_msg = pmt.to_pmt(hdlc_frame)

              self.message_port_pub(pmt.intern('msg_out'), outgoing_msg)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          PDU_in: 1,0,1,0,1,0,1,0 (ex)
          PDU_out: 0xAA
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Pack 8 bits',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bitstream = np.array(pmt.to_python(pmt.cdr(msg)))
              bytestream = np.packbits(bitstream)


              #Convert the bytestream to PDU
              outgoing_msg = pmt.init_u8vector(len(bytestream),(bytestream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          PDU_in: 0xAE (ex.)
          PDU_out: 1,0,1,0,1,1,1,0
          """

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Unpack 8 bits',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)


          def handle_msg(self, msg):
              bytestream = np.array(pmt.to_python(pmt.cdr(msg))) 
              bitstream = np.unpackbits(bytestream)

              #Convert the bytestream to PDU
              outgoing_msg = pmt.init_u8vector(len(bitstream),(bitstream))
              pdu = pmt.cons(pmt.make_dict(), outgoing_msg)

              self.message_port_pub(pmt.intern('PDU_out'), pdu)
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-371e3'
    comment: |-
      Decimate and translate to 437 MHz
      for HackRF
    decim: '100'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -30e3, 30e3, 5e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-500e3'
    comment: |-
      Decimate and translate to 437 MHz
      for RTLSDR
    decim: '40'
    samp_rate: 3.2e6
    taps: firdes.complex_band_pass(1, samp_rate, -30e3, 30e3, 5e3)
    type: ccc
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    nconnections: '2'
    size: 1024*10
    srate: 80e3
    style1: '0'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: View sampled spectrum
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '1'
  states: {}
- name: satellites_fsk_demodulator_1
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    comment: |-
      Timing synchronization
      and soft bit output
    samp_rate: samp_rate/100
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    comment: |-
      Find sync sequence and create 
      a PDU if found
    packlen: '700'
    sync: '"0101010101010101010101010111111010101010"'
    threshold: '0'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: 437.5e6
    comment: |-
      NOTE: RX Sink  center frequency 
      should be kept at 437.5 MHz
      The flowgraph will isolate the signal at 437 MHz
      automatically. (avoids RX DC offset)
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 437.5e6
    comment: |-
      NOTE: RX Sink  center frequency 
      should be kept at 437.5 MHz
      The flowgraph will isolate the signal at 437 MHz
      automatically. (avoids RX DC offset)
    samp_rate: 3.2e6
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: synced_message
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: 'From here: FEC and descambling etc'
    stream_id: synced_message
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_agc_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_1, '1']
- [digital_binary_slicer_fb_1, '0', blocks_uchar_to_float_1, '0']
- [digital_binary_slicer_fb_1, '0', satellites_sync_to_pdu_0, '0']
- [epy_block_0_0, pdu_out, epy_block_0_1, PDU_in]
- [epy_block_0_1, PDU_out, epy_block_2, PDU_in]
- [epy_block_1, msg_out, epy_block_0_0, msg_in]
- [epy_block_2, PDU_out, satellites_decode_rs_ccsds_0, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [satellites_decode_rs_ccsds_0, out, blocks_message_debug_1, print]
- [satellites_decode_rs_ccsds_0, out, disco_ZMQ_sink_0, PDU_in]
- [satellites_fsk_demodulator_1, '0', digital_binary_slicer_fb_1, '0']
- [satellites_fsk_demodulator_1, '0', qtgui_time_sink_x_1, '0']
- [satellites_sync_to_pdu_0, out, virtual_sink_1, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', satellites_fsk_demodulator_1, '0']
- [virtual_source_1, '0', epy_block_1, msg_in]

metadata:
  file_format: 1
